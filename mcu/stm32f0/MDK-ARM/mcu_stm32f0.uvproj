# Keil uVision project mcu_stm32f0.uvproj, settings and files
target STM32F051x8 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: mcu +hex (library)
  AfterMake: Z:\junfenggeng\kuaipan\btsdk\mcu\stm32f0\MDK-ARM\install.bat
  c flags: OneElfS=1 wLevel=2
  c define: STM32F051x8,USE_HAL_DRIVER
  c include: ..\..\cmsis\inc;..\device\inc;..\hal\inc;..\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group hal
    ../hal/src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_crc.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_wwdg.c
  group stm32f051x8
    ../device/src/: startup_stm32f051x8.s
  group user
    ../user/src/: syscfg_stm32f0xx.c system_stm32f0xx.c
