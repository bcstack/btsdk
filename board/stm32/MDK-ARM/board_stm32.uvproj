# Keil uVision project board_stm32.uvproj, settings and files
target STM32F051-Discovery (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: board +hex (library)
  AfterMake: Z:\junfenggeng\kuaipan\btsdk\board\stm32\MDK-ARM\install.bat
  c flags: OneElfS=1 wLevel=2
  c define: STM32F051x8,USE_HAL_DRIVER
  c include: ..\..\..\mcu\cmsis\inc;..\..\..\mcu\stm32f0\device\inc;..\..\..\mcu\stm32f0\user\inc;..\..\..\mcu\stm32f0\hal\inc;..\..\inc;..\f051
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group board
    ../src/: board.c
