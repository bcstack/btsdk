# Keil uVision project bt.uvproj, settings and files
target STM32F051x8 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: bt +hex (library)
  AfterMake: Z:\junfenggeng\kuaipan\btsdk\bluetooth\MDK-ARM\install.bat
  c flags: OneElfS=1 wLevel=2
  c include: ..\inc;..\..\system\inc;..\..\board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group stack
    ../src/: bluetooth.c gap.c gap-const.c hci-h4.c l2cap.c gatt.c rfcomm.c sdp.c spp_sdp.c
target STM32F030 (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: as above
  output: bt +hex (library)
  AfterMake: Z:\junfenggeng\kuaipan\btsdk\bluetooth\MDK-ARM\install.bat
  c flags: OneElfS=1 wLevel=2
  c include: ..\inc;..\..\system\inc;..\..\board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
