# Keil uVision project led.uvproj, settings and files
target STM32F051x8 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: btsdk-stm32f051 +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F051x8,USE_HAL_DRIVER
  c include: ..\user;..\..\..\bluetooth\inc;..\..\..\board\inc;..\..\..\system\inc;..\..\..\mcu\cmsis\inc;..\..\..\mcu\stm32f0\device\inc;..\..\..\mcu\stm32f0\hal\inc;..\..\..\mcu\stm32f0\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../user/: main.c
  group lib
    ../../../workspace/build/: board.lib bt.lib mcu.lib system.lib
  group f030
    ../user/: led-f030.c
  group f051
    ../user/: led-f051.c
target STM32F030F4 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: lightmagic-stm32f030 +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F030x8,USE_HAL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
